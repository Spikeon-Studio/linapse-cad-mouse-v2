#include <Arduino.h>

#include "Config.h"
#include "Controllers.h"
#include "HidSerialCommand.h"
#include "LedConfig.h"
#include "SensConfig.h"
#include "StateMachine.h"

InputController    inputController;
LEDController      ledController;
SensorController   sensorController;
MotionController   motionController;
HIDController      hidController;
TelemetryController telemetryController;
TapDetector        tapDetector;
EffectEngine       effectEngine;

// ── Serial command handler ────────────────────────────────────────────────────
// Commands:
//   led show                    — print brightness/color/effect
//   led brightness <0-255>      — set brightness
//   led color <RRGGBB>          — set idle color
//   led effect <name>           — set effect (see below)
//   led reset                   — restore defaults
//   config get                  — JSON dump of all config
//   config reset                — factory reset

bool g_debugAxes = false;  // accessed by IdleState
int g_currentVolume = 50;  // accessed by EffectEngine
int g_eqLevels[8] = {0};   // accessed by EffectEngine
bool g_serviceHidMode = false;
bool g_serviceButtonMode = false;
unsigned long g_lastServicePacketMs = 0;
long  g_sleepTimeoutMs     = -1;    // accessed by IdleState; -1 = disabled
float g_sleepWakeThreshold = 15.0f; // accessed by SleepState

namespace {
String serialBuf;

const char* effectName(LedEffect fx) {
  switch (fx) {
    case LedEffect::Solid:         return "solid";
    case LedEffect::Breathing:     return "breathing";
    case LedEffect::Reactive:      return "reactive";
    case LedEffect::DotSwirl:      return "dot_swirl";
    case LedEffect::GradientSwirl: return "gradient_swirl";
    case LedEffect::RainbowSwirl:  return "rainbow_swirl";
    case LedEffect::Volume:        return "volume";
    case LedEffect::Equalizer:     return "equalizer";
    default:                       return "unknown";
  }
}

LedEffect effectFromName(const String& name) {
  if (name == "solid")          return LedEffect::Solid;
  if (name == "breathing")      return LedEffect::Breathing;
  if (name == "reactive")       return LedEffect::Reactive;
  if (name == "dot_swirl")      return LedEffect::DotSwirl;
  if (name == "gradient_swirl") return LedEffect::GradientSwirl;
  if (name == "rainbow_swirl")  return LedEffect::RainbowSwirl;
  if (name == "volume")         return LedEffect::Volume;
  if (name == "equalizer")      return LedEffect::Equalizer;
  return LedEffect::kCount;  // invalid sentinel
}

void applyAndSave() {
  ledConfig.save();
  effectEngine.configure(ledConfig.effect, ledConfig.idleColor, ledConfig.brightness);
}

void handleLedCommand(const String& args) {
  if (args == "show") {
    char buf[64];
    snprintf(buf, sizeof(buf), "brightness=%d color=%06lX effect=%s\n",
             ledConfig.brightness, (unsigned long)ledConfig.idleColor,
             effectName(ledConfig.effect));
    Serial.print(buf);
    return;
  }
  if (args == "reset") {
    ledConfig.reset();
    applyAndSave();
    Serial.println("OK reset");
    return;
  }
  if (args.startsWith("brightness ")) {
    int val = args.substring(11).toInt();
    if (val < 0 || val > 255) { Serial.println("ERR brightness 0-255"); return; }
    ledConfig.brightness = (uint8_t)val;
    applyAndSave();
    Serial.println("OK");
    return;
  }
  if (args.startsWith("color ")) {
    String hex = args.substring(6); hex.trim();
    if (hex.length() != 6) { Serial.println("ERR color RRGGBB"); return; }
    ledConfig.idleColor = (uint32_t)strtoul(hex.c_str(), nullptr, 16);
    applyAndSave();
    Serial.println("OK");
    return;
  }
  if (args.startsWith("effect ")) {
    String name = args.substring(7); name.trim();
    LedEffect fx = effectFromName(name);
    if (fx == LedEffect::kCount) {
      Serial.println("ERR effect: solid|breathing|reactive|dot_swirl|gradient_swirl|rainbow_swirl|volume|equalizer");
      return;
    }
    ledConfig.effect = fx;
    applyAndSave();
    Serial.println("OK");
    return;
  }
  Serial.println("ERR unknown: led show|brightness N|color RRGGBB|effect NAME|reset");
}

void handleConfigCommand(const String& args) {
  if (args == "get") {
    char buf[280];
    snprintf(buf, sizeof(buf),
             "{\"brightness\":%d,\"color\":\"%06lX\",\"effect\":\"%s\","
             "\"dead_t\":%.2f,\"dead_r\":%.2f,\"kalman_q\":%.3f,\"kalman_r\":%.3f,\"exp\":%.2f,"
             "\"tap_sens\":%.3f,\"invert_tap_z\":%d,\"spherical\":%d,\"spring_head\":%d,"
             "\"despike_enabled\":%d,\"despike_threshold\":%.2f,\"despike_strength\":%.2f}\n",
             ledConfig.brightness, (unsigned long)ledConfig.idleColor,
             effectName(ledConfig.effect),
             sensConfig.deadT, sensConfig.deadR,
             sensConfig.kalmanQ, sensConfig.kalmanR,
             sensConfig.sensitivityExp,
             sensConfig.tapThreshold,
             sensConfig.invertTapZ ? 1 : 0,
             sensConfig.sphericalMode ? 1 : 0,
             sensConfig.springHead ? 1 : 0,
             sensConfig.despikeEnabled ? 1 : 0,
             sensConfig.despikeThreshold,
             sensConfig.despikeStrength);
    Serial.print(buf);
    return;
  }
  if (args == "reset") {
    ledConfig.reset();
    applyAndSave();
    Serial.println("OK reset");
    return;
  }
  Serial.println("ERR unknown: config get|reset");
}

void handleSensCommand(const String& args) {
  if (args == "get") {
    char buf[280];
    snprintf(buf, sizeof(buf),
             "{\"dead_t\":%.2f,\"dead_r\":%.2f,\"kalman_q\":%.3f,\"kalman_r\":%.3f,\"exp\":%.2f,"
             "\"tap_sens\":%.3f,\"invert_tap_z\":%d,\"spherical\":%d,\"spring_head\":%d,"
             "\"despike_enabled\":%d,\"despike_threshold\":%.2f,\"despike_strength\":%.2f}\n",
             sensConfig.deadT, sensConfig.deadR,
             sensConfig.kalmanQ, sensConfig.kalmanR,
             sensConfig.sensitivityExp,
             sensConfig.tapThreshold,
             sensConfig.invertTapZ ? 1 : 0,
             sensConfig.sphericalMode ? 1 : 0,
             sensConfig.springHead ? 1 : 0,
             sensConfig.despikeEnabled ? 1 : 0,
             sensConfig.despikeThreshold,
             sensConfig.despikeStrength);
    Serial.print(buf);
    return;
  }
  if (args == "reset") {
    sensConfig.reset();
    sensConfig.save();
    Serial.println("OK reset");
    return;
  }
  if (args.startsWith("set ")) {
    String rest = args.substring(4);
    int sp = rest.indexOf(' ');
    if (sp < 0) { Serial.println("ERR sens set <param> <value>"); return; }
    String param = rest.substring(0, sp);
    float  val   = rest.substring(sp + 1).toFloat();
    if      (param == "dead_t")   sensConfig.deadT = val;
    else if (param == "dead_r")   sensConfig.deadR = val;
    else if (param == "kalman_q") sensConfig.kalmanQ = val;
    else if (param == "kalman_r") sensConfig.kalmanR = val;
    else if (param == "exp")      sensConfig.sensitivityExp = val;
    else if (param == "tap_sens")     sensConfig.tapThreshold = val;
    else if (param == "invert_tap_z") sensConfig.invertTapZ = (val > 0.5f);
    else if (param == "spherical")    sensConfig.sphericalMode = (val > 0.5f);
    else if (param == "spring_head")  sensConfig.springHead = (val > 0.5f);
    else if (param == "despike_enabled")   sensConfig.despikeEnabled   = (val > 0.5f);
    else if (param == "despike_threshold") sensConfig.despikeThreshold = val;
    else if (param == "despike_strength")  sensConfig.despikeStrength  = val;
    else { Serial.println("ERR unknown sens param"); return; }
    sensConfig.save();
    Serial.println("OK");
    return;
  }
  Serial.println("ERR unknown: sens get|set <param> <val>|reset");
}

void handleSleepCommand(const String& args) {
  if (args == "get") {
    char buf[64];
    snprintf(buf, sizeof(buf), "{\"sleep_timeout_ms\":%ld,\"sleep_wake_threshold\":%.2f}\n",
             g_sleepTimeoutMs, g_sleepWakeThreshold);
    Serial.print(buf);
    return;
  }
  if (args.startsWith("set timeout ")) {
    g_sleepTimeoutMs = atol(args.c_str() + 12);
    Serial.println("OK");
    return;
  }
  if (args.startsWith("set threshold ")) {
    g_sleepWakeThreshold = atof(args.c_str() + 14);
    Serial.println("OK");
    return;
  }
  Serial.println("ERR unknown: sleep get|set timeout <ms>|set threshold <val>");
}

void handleDebugCommand(const String& args) {
  if (args == "axes on")  { g_debugAxes = true;  Serial.println("OK debug axes on");  return; }
  if (args == "axes off") { g_debugAxes = false; Serial.println("OK debug axes off"); return; }
  if (args == "baseline") {
    const float* bl = sensorController.baseline();
    char buf[128];
    snprintf(buf, sizeof(buf), "baseline:%.2f,%.2f,%.2f,%.2f,%.2f,%.2f,%.2f,%.2f,%.2f\n",
             bl[0], bl[1], bl[2], bl[3], bl[4], bl[5], bl[6], bl[7], bl[8]);
    Serial.print(buf);
    return;
  }
  Serial.println("ERR unknown: debug axes on|off|baseline");
}


void handleSerial() {
  while (Serial.available()) {
    char c = (char)Serial.read();
    if (c == '\n' || c == '\r') {
      serialBuf.trim();
      if      (handleHidSerialCommand(serialBuf, hidController)) { /* handled */ }
      else if (serialBuf.startsWith("led "))    handleLedCommand(serialBuf.substring(4));
      else if (serialBuf.startsWith("config ")) handleConfigCommand(serialBuf.substring(7));
      else if (serialBuf.startsWith("sens "))   handleSensCommand(serialBuf.substring(5));
      else if (serialBuf.startsWith("sleep "))  handleSleepCommand(serialBuf.substring(6));
      else if (serialBuf.startsWith("debug "))  handleDebugCommand(serialBuf.substring(6));
      else if (serialBuf == "version")          { Serial.println("version=2.27.1"); }
      else if (serialBuf.startsWith("volume ")) {
        int val = atoi(serialBuf.c_str() + 7);
        if (val >= 0 && val <= 100) {
          g_currentVolume = val;
          Serial.println("OK");
        } else {
          Serial.println("ERR volume 0-100");
        }
      }
      else if (serialBuf.startsWith("eq ")) {
        const char* p = serialBuf.c_str() + 3;
        bool ok = true;
        int temp[8] = {0};
        for (int i = 0; i < 8; i++) {
          while (*p == ' ') p++;
          if (*p == '\0') {
            ok = false;
            break;
          }
          char* next;
          long val = strtol(p, &next, 10);
          if (p == next) {
            ok = false;
            break;
          }
          temp[i] = (int)val;
          p = next;
        }
        if (ok) {
          bool valid = true;
          for (int i = 0; i < 8; i++) {
            if (temp[i] < 0 || temp[i] > 100) {
              valid = false;
              break;
            }
          }
          if (valid) {
            for (int i = 0; i < 8; i++) {
              g_eqLevels[i] = temp[i];
            }
            Serial.println("OK");
          } else {
            Serial.println("ERR eq bounds 0-100");
          }
        } else {
          Serial.println("ERR eq <8 levels>");
        }
      }
      serialBuf = "";
    } else {
      if (serialBuf.length() < 255) {
        serialBuf += c;
      } else {
        serialBuf = "";
      }
    }
  }
}
}  // namespace

// ── Arduino entry points ──────────────────────────────────────────────────────

void setup() {
  pinMode(Config::PIN_LEFT_BTN, INPUT_PULLUP);
  pinMode(Config::PIN_RIGHT_BTN, INPUT_PULLUP);
  if (digitalRead(Config::PIN_LEFT_BTN) == LOW && digitalRead(Config::PIN_RIGHT_BTN) == LOW) {
    rp2040.rebootToBootloader();
  }

  hidController.begin();
  Serial.begin(115200);
  serialBuf.reserve(256);
  if (Config::ENABLE_TELEMETRY) { delay(200); }

  ledConfig.load();
  sensConfig.load();
  effectEngine.configure(ledConfig.effect, ledConfig.idleColor, ledConfig.brightness);

  inputController.begin();
  ledController.begin();
  sensorController.begin();
  motionController.reset();
  tapDetector.reset();
  telemetryController.begin();

  stateMachine.changeState(&StateMachine::calibratingState);
}

void loop() {
  hidController.task();
  handleSerial();

  static unsigned long lastUpdate = 0;
  unsigned long now = millis();
  if (now - lastUpdate >= 10) {  // 100Hz polling rate
    lastUpdate = now;
    stateMachine.update();
  }
}
